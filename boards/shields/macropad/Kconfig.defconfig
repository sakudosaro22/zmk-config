## boards/shields/macropad/Kconfig.defconfig
```kconfig
if SHIELD_MACROPAD

config ZMK_KEYBOARD_NAME
    default "Macropad"

config ZMK_SPLIT
    default n

endif # SHIELD_MACROPAD
```
